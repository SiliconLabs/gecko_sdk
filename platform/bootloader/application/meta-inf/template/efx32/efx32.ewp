# IAR project efx32.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: $--partNumber;U--$ SiliconLaboratories $--partNumber;U--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; $--partNumber;U--$
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--frameworkDirFromProjBs--$\..\$--deviceDir--$\SiliconLabs\$--chipFamily;U--$\Include; $--frameworkDirFromProjBs--$\..\$--cmsisDir--$\Include; $--frameworkDirFromProjBs--$\..\$--halconfigDir--$\inc\hal-config; $--frameworkDirFromProjBs--$\..\..\hardware\module\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--frameworkDirFromProjBs--$\..\$--deviceDir--$\SiliconLabs\$--chipFamily;U--$\Include; $--frameworkDirFromProjBs--$\..\$--cmsisDir--$\Include; $--frameworkDirFromProjBs--$\..\$--halconfigDir--$\inc\hal-config
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkIcfFile: $--linkerIcfFile--$
  ILINK.IlinkAdditionalLibs: $--linkerLibraryFile--$
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: $--partNumber;U--$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--frameworkDirFromProjBs--$\..\$--deviceDir--$\SiliconLabs\$--chipFamily;U--$\Include; $--frameworkDirFromProjBs--$\..\$--cmsisDir--$\Include
  group Device
    $--frameworkDirFromProjBs--$/../$--deviceDir--$/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
